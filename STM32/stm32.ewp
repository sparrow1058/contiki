# IAR project stm32.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103x8 ST STM32F103x8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: PLATFORM_HEADER=mytype.h
  ICCARM.CCIncludePath2: $PROJ_DIR$; Libraries\CMSIS\CM3\CoreSupport; Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x; Libraries\STM32F10x_StdPeriph_Driver\inc; contiki\core; contiki\core\sys; contiki\core\lib; contiki\cpu; lcd
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: stm32.hex
  ILINK.IlinkOutputFile: stm32.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group CMSIS
    Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group Contiki/core/sys
    contiki/core/sys/: autostart.c etimer.c process.c procinit.c timer.c
  group Contiki/cpu
    contiki/cpu/arm/stm32f103/: clock.c
  group lcd
    lcd/: contiki-main.c delay.c GUI.c Lcd_Driver.c led.c stm32f10x_it.c TFT_demo.c uart.c
  group Std_Driver
    Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_usart.c
